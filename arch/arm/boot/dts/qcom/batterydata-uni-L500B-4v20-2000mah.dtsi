/**********uniscope-driver-modify-file-on-qualcomm-platform*****************/
/* Copyright (c) 2014, The Linux Foundation. All rights reserved.
 *
 * This program is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License version 2 and
 * only version 2 as published by the Free Software Foundation.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 */


qcom,qrd-skue-4v20-2000mah-data {
	qcom,default-rbatt-mohm = <168>;
	qcom,max-voltage-uv = <4200000>;
	qcom,fcc-mah = <2000>;
	qcom,rbatt-capacitive-mohm = <50>;
	qcom,v-cutoff-uv = <3400000>;
	qcom,chg-term-ua = <100000>;
	qcom,batt-id-kohm = <110>;
	qcom,flat-ocv-threshold-uv = <3800000>;
	qcom,battery-type = "qrd_skue_4v20_2000mah";

	qcom,fcc-temp-lut {
		qcom,lut-col-legend = <(-20) 0 25 40 60>;
		qcom,lut-data = <1925 1971 1962 1955 1949>;
	};

	qcom,pc-temp-ocv-lut {
		qcom,lut-col-legend = <(-20) 0 25 40 60>;
		qcom,lut-row-legend = <100 95 90 85 80>,
				<75 70 65 60 55>,
				<50 45 40 35 30>,
				<25 20 16 13 11>,
				<10 9 8 7 6>,
				<5 4 3 2 1>,
				<0>;
		qcom,lut-data = 
				{4191 4188 4186 4182 4176},
				{4110 4123 4126 4126 4122},
				{4056 4076 4082 4081 4078},
				{3997 4026 4040 4040 4038},
				{3946 3976 4000 4002 4000},
				{3910 3939 3966 3968 3966},
				{3876 3907 3933 3936 3934},
				{3847 3877 3896 3904 3903},
				{3820 3849 3861 3866 3868},
				{3796 3825 3834 3836 3836},
				{3776 3802 3814 3814 3814},
				{3760 3782 3798 3798 3798},
				{3745 3764 3784 3785 3783},
				{3730 3750 3772 3772 3770},
				{3715 3740 3760 3759 3752},
				{3697 3730 3748 3742 3732},
				{3676 3720 3730 3724 3711},
				{3653 3710 3709 3704 3691},
				{3632 3700 3694 3686 3673},
				{3613 3692 3684 3676 3666},
				{3603 3686 3682 3674 3664},
				{3592 3679 3680 3672 3662},
				{3580 3671 3678 3671 3660},
				{3568 3662 3675 3668 3656},
				{3553 3648 3668 3661 3650},
				{3534 3630 3651 3643 3630},
				{3509 3602 3617 3608 3594},
				{3476 3564 3568 3560 3546},
				{3434 3510 3506 3498 3484},
				{3376 3426 3420 3416 3414},
				{3300 3300 3300 3300 3306};
};

	qcom,rbatt-sf-lut {
		qcom,lut-col-legend = <(-20) 0 25 40 60>;
		qcom,lut-row-legend = <100 95 90 85 80>,
				<75 70 65 60 55>,
				<50 45 40 35 30>,
				<25 20 16 13 11>,
				<10 9 8 7 6>,
				<5 4 3 2 1>;
		qcom,lut-data = 
				{1035 287 101 79 70},
				{1035 287 101 79 70},
				{1014 293 107 82 71},
				{989 293 112 85 73},
				{977 292 117 88 75},
				{981 293 124 92 77},
				{992 295 126 97 80},
				{1005 295 118 100 85},
				{1029 295 108 90 81},
				{1067 296 104 83 74},                       
				{1120 296 105 82 73},                       
				{1190 296 106 83 74},                       
				{1281 296 108 87 77},                       
				{1392 299 111 87 79},                       
				{1535 310 110 86 76},                       
				{1726 326 112 83 73},                       
				{2002 351 111 84 74},                       
				{2311 374 108 83 74},                       
				{2621 392 107 82 73},                       
				{2924 398 105 81 73},                       
				{3080 396 108 82 74},                       
				{3256 374 111 84 76},                       
				{3469 367 113 86 76},                       
				{3522 378 118 88 77},                       
				{3625 389 123 90 79},                       
				{4031 404 122 88 77},                       
				{4595 424 116 85 74},                       
				{5327 455 115 87 77},                       
				{6415 500 121 90 80},                       
				{8315 642 136 102 88};    
	};

	qcom,ibat-acc-lut {
		qcom,lut-col-legend = <(-20) 0 25>;
		qcom,lut-row-legend = <0 250 500 1000>;
		qcom,lut-data = <1896 1951 1942>,
				<649  1852 1904>,
				<145  1710 1892>,
				<6   1139 1846>;
	};
};
